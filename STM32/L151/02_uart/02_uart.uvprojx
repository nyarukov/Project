# Keil uVision project 02_uart.uvprojx, settings and files
target uart (6140001::V6.14.1::ARMCLANG)
  device: STM32L151C8TxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 02_uart +hex
  c flags: Optim=3 v6Lang=3 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32L1XX_MD
  c include: .\Drive\app;.\Drive;.\Lib;.\Start;.\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group User
    ./User/: main.c stm32l1xx_conf.h stm32l1xx_it.c stm32l1xx_it.h
  group Start
    ./Start/: core_cm3.h core_cmFunc.h core_cmInstr.h startup_stm32l1xx_md.s stm32l1xx.h system_stm32l1xx.c system_stm32l1xx.h
  group Lib
    ./Lib/: misc.c misc.h stm32l1xx_adc.c stm32l1xx_adc.h stm32l1xx_aes.c stm32l1xx_aes.h stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_comp.h stm32l1xx_crc.c stm32l1xx_crc.h stm32l1xx_dac.c stm32l1xx_dac.h stm32l1xx_dbgmcu.c stm32l1xx_dbgmcu.h stm32l1xx_dma.c stm32l1xx_dma.h stm32l1xx_exti.c stm32l1xx_exti.h stm32l1xx_flash.c stm32l1xx_flash.h stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_fsmc.h stm32l1xx_gpio.c stm32l1xx_gpio.h stm32l1xx_i2c.c stm32l1xx_i2c.h stm32l1xx_iwdg.c stm32l1xx_iwdg.h stm32l1xx_lcd.c stm32l1xx_lcd.h stm32l1xx_opamp.c stm32l1xx_opamp.h stm32l1xx_pwr.c stm32l1xx_pwr.h stm32l1xx_rcc.c stm32l1xx_rcc.h stm32l1xx_rtc.c stm32l1xx_rtc.h stm32l1xx_sdio.c stm32l1xx_sdio.h stm32l1xx_spi.c stm32l1xx_spi.h stm32l1xx_syscfg.c stm32l1xx_syscfg.h stm32l1xx_tim.c stm32l1xx_tim.h stm32l1xx_usart.c stm32l1xx_usart.h stm32l1xx_wwdg.c stm32l1xx_wwdg.h
  group Drive
    ./Drive/: dma.c dma.h iic.c iic.h myspi.c myspi.h oled.c oled.h oledfont.h spi.c spi.h timer.c timer.h led.c led.h key.c key.h
    ./Drive/app/: mpu6050.c mpu6050.h W25Q32.c W25Q32.h
