# Keil uVision project uart.uvprojx, settings and files
target uart (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L151C8TxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32L1XX_MD
  c include: .\User;.\Start;.\Lib;.\Drive
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Start
    ./Start/: core_cm0.h core_cm3.h core_cm4.h startup_stm32l1xx_md.s stm32l1xx.h system_stm32l1xx.c system_stm32l1xx.h core_cmInstr.h core_cmFunc.h
  group Lib
    ./Lib/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group User
    ./User/: main.c stm32l1xx_conf.h stm32l1xx_it.c stm32l1xx_it.h
