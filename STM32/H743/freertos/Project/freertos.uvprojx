# Keil uVision project freertos.uvprojx, settings and files
target freertos (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: freertos +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ..\CMSIS\Include;..\CMSIS\Device\ST\STM32H7xx\Include;..\STM32H7xx_HAL_Driver\Inc;..\STM32H7xx_HAL_Driver\Inc\Legacy;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\CMSIS_RTOS_V2;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\Drive\App;..\Core\Inc;..\Drive\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group STM32H7xx_HAL_Driver
    ../STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group CMSIS
    ../CMSIS/Device/ST/STM32H7xx/Source/: system_stm32h7xx.c startup_stm32h743xx.s
  group Core
    ../Core/Src/: main.c stm32h7xx_it.c
  group Drive
    ../Drive/Src/: bsp.c bsp_bmp.c bsp_btim.c bsp_cpu_flash.c bsp_exti.c bsp_flash.c bsp_ft5426.c bsp_hard_i2c.c bsp_hard_spi.c bsp_key.c bsp_led.c bsp_ltdc_draw.c bsp_ltdc_driver.c bsp_mpu.c bsp_mpu6050.c bsp_qspi.c bsp_qspi_w25q128.c bsp_rcc.c bsp_sdio_sd.c bsp_sdram.c bsp_soft_i2c.c bsp_soft_spi.c bsp_uart.c bsp_w25q128.c
  group FreeRTSO
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/CMSIS_RTOS_V2/: cmsis_os2.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.4.0
