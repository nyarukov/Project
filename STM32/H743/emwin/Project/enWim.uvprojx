# Keil uVision project enWim.uvprojx, settings and files
target emWin (6140001::V6.14.1::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: emWin +hex
  AfterMake: fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ..\CMSIS\Device\Include;..\CMSIS\Include;..\STM32H7xx_HAL_Driver\Inc\Legacy;..\STM32H7xx_HAL_Driver\Inc;..\Core\Inc;..\Drive\Inc;..\enWim\Config;..\enWim\emWin_Demo;..\enWim\Inc;..\enWim\Lib;..\enWim\OS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group STM32H7xx_HAL_Driver
    ../STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_sdram.c stm32h7xx_ll_fmc.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_fmac.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group CMSIS
    ../CMSIS/Device/Source/: startup_stm32h743xx.s
  group Core
    ../Core/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c system_stm32h7xx.c
  group Drive
    ../Drive/Src/: bsp.c bsp_bmp.c bsp_exti.c bsp_key.c bsp_led.c bsp_ltdc_draw.c bsp_ltdc_driver.c bsp_mpu.c bsp_rcc.c bsp_sdram.c bsp_softiic.c bsp_softspi.c bsp_uart.c bsp_btim.c bsp_ft5426.c bsp_mpu6050.c
  group emWin/Config
    ../enWim/Config/: LCDConf.c GUIDRV_Template.c GUIConf.c GUI_X_Touch_Analog.c
  group emWin/Demo
    ../enWim/emWin_Demo/: MainTask.c
  group emWin/OS
    ../enWim/OS/: GUI_X.c
  group emWin/Lib
    ../enWim/Lib/: GUI_CM4F_L.lib
software components: CMSIS:CORE 5.4.0
