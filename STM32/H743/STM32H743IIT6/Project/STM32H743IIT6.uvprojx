# Keil uVision project STM32H743IIT6.uvprojx, settings and files
target end (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: end +hex
  AfterMake: fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ..\CMSIS\Device\Include;..\CMSIS\Include;..\STM32H7xx_HAL_Driver\Inc\Legacy;..\STM32H7xx_HAL_Driver\Inc;..\Core\Inc;..\BSP\Inc;..\Middlewares\lvgl;..\Middlewares\lvgl\src;..\Middlewares\lvgl\porting;..\Middlewares\lvgl\demos;..\Middlewares\lvgl\demos\components;..\Middlewares\FreeRTOS;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\CMSIS_RTOS_V2;..\Middlewares\FreeRTOS\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group STM32H7xx_HAL_Driver
    ../STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_sdram.c stm32h7xx_ll_fmc.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_fmac.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c
  group CMSIS
    ../CMSIS/Device/Source/: startup_stm32h743xx.s
  group Core
    ../Core/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c system_stm32h7xx.c
  group Bsp
    ../BSP/Src/: bsp.c bsp_bmp.c bsp_bmp280.c bsp_btim.c bsp_cmd.c bsp_cpu_flash.c bsp_exti.c bsp_ft5426.c bsp_hard_i2c.c bsp_hard_spi.c bsp_key.c bsp_led.c bsp_ltdc_draw.c bsp_ltdc_driver.c bsp_modbus.c bsp_mpu.c bsp_mpu6050.c bsp_qspi.c bsp_qspi_w25q128.c bsp_rcc.c bsp_sdio_sd.c bsp_sdram.c bsp_soft_i2c.c bsp_soft_spi.c bsp_systick.c bsp_uart.c bsp_w25q128.c
  group LVGL/point
    ../Middlewares/lvgl/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group LVGL/src
    ../Middlewares/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Middlewares/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares/lvgl/src/draw/nxp_pxp/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../Middlewares/lvgl/src/draw/nxp_vglite/: lv_gpu_nxp_vglite.c
    ../Middlewares/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Middlewares/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Middlewares/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../Middlewares/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Middlewares/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Middlewares/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Middlewares/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Middlewares/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Middlewares/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Middlewares/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Middlewares/lvgl/src/extra/libs/qrcode/: lv_qrcode.c
    ../Middlewares/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Middlewares/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Middlewares/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Middlewares/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Middlewares/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Middlewares/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Middlewares/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Middlewares/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Middlewares/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Middlewares/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Middlewares/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middlewares/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middlewares/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/lvgl/src/extra/widgets/led/: lv_led.c
    ../Middlewares/lvgl/src/extra/widgets/list/: lv_list.c
    ../Middlewares/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Middlewares/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Middlewares/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/lvgl/src/extra/widgets/span/: lv_span.c
    ../Middlewares/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Middlewares/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Middlewares/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Middlewares/lvgl/src/extra/widgets/win/: lv_win.c
    ../Middlewares/lvgl/src/extra/: lv_extra.c
    ../Middlewares/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Middlewares/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Middlewares/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Middlewares/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL/Demo
    ../Middlewares/lvgl/demos/: ui.c ui_helpers.c
    ../Middlewares/lvgl/demos/screens/: ui_Screen1.c
    ../Middlewares/lvgl/demos/components/: ui_comp.c ui_comp_hook.c ui_comp_screen1_label1.c
  group FreeRTOS/Src
    ../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/FreeRTOS/CMSIS_RTOS_V2/: cmsis_os2.c
  group FreeRTOS/Demo
    ../Middlewares/FreeRTOS/APP/: freertos_demo.c
software components: CMSIS:CORE 5.4.0
