# Keil uVision project project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\..\libs\inc;..\..\libs\stm32_lib\inc;..\..\src\config;..\..\src\utils;..\..\src\drivers;..\..\src\protocol;..\..\src\peripherals
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group libs\assembly
    ../../libs/assembly/: startup_stm32f40_41xxx.s
  group libs\inc
    ../../libs/inc/: stm32f4xx_it.c system_stm32f4xx.c
  group libs\stm32_lib
    ../../libs/stm32_lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group src\utils
    ../../src/utils/: buffer.c lib.c Routin_Module.c list.h middle.h buffer.h def.h lib.h Routin_Module.h
  group src\config
    ../../src/config/: config.c
  group src\drivers
    ../../src/drivers/: gpio.c hard_i2c.c hard_spi.c soft_i2c.c soft_spi.c systick.c time.c uart.c
  group src\protocol
    ../../src/protocol/: modbus_master.c modbus_slave.c xmode.c ymode.c
  group src\peripherals
    ../../src/peripherals/: main.c
