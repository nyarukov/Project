# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Start;..\Library;..\User;..\Bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Start
    ../Start/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Library
    ../Library/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../User/: main.c stm32f10x_it.c
  group Bsp
    ../Bsp/scr/: bsp_adc.c bsp_esp8266.c bsp_key.c bsp_led.c bsp_soft_i2c.c bsp_soft_spi.c bsp_systick.c bsp_uart.c bsp_user_lib.c bsp_i2c_app.c bsp_oled.c bsp_oled_app.c bsp_pwm.c oled_font.c multi_button.c bsp_cpu_flash.c bsp_adc_app.c
